# Keil uVision project FlightController.uvproj, settings and files
target FlightController (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: FlightController
  c flags: Optim=1 uC99=1
  c define: STM32F40XX, USE_STDPERIPH_DRIVER, HSE_VALUE = 8000000
  c include: .\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Include
  memory RVCT4: ROM 0x8000000 size 0x3e80
  memory RVCT5: ROM 0x8008000 size 0xf8300
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Project Code
    Source./: main.c
    ./Source/: scheduler.c protocol.c telegram.c
    ./source/: imu.c pid.c sensors.c utilities.c checksum.c
    ./Include/: commandlibrary.h
  group Hardware
    ./source/: rc.c spi.c motor.c
    ./Include/: pinout.h
    ./Source/: ledbutton.c time.c serial.c memory.c
  group CMSIS
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group MDK-ARM
    ./Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group Standard Pheripherals Library
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_flash.c
